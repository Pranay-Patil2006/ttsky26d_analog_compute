v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {blocks/I_V_conv.sym} -120 -10 0 0 {name=x1}
C {vsource.sym} 150 -50 0 0 {name=V1 value=1.8 savecurrent=false}
C {vsource.sym} 290 -50 0 0 {name=V2 value=1 savecurrent=false}
C {isource.sym} 400 -50 0 0 {name=I0 value=2.5u}
C {lab_wire.sym} 30 -50 0 1 {name=p1 lab=VDD}
C {lab_wire.sym} 30 -30 0 1 {name=p2 lab=i_in}
C {lab_wire.sym} 30 -10 0 1 {name=p3 lab=v_out}
C {lab_wire.sym} 30 10 0 1 {name=p4 lab=vref}
C {lab_wire.sym} 30 30 0 1 {name=p5 lab=GND}
C {lab_wire.sym} 150 -80 0 1 {name=p6 lab=VDD}
C {lab_wire.sym} 400 -80 0 1 {name=p7 lab=vref}
C {lab_wire.sym} 150 -20 0 1 {name=p8 lab=GND}
C {lab_wire.sym} 290 -20 0 1 {name=p9 lab=GND}
C {lab_wire.sym} 400 -20 0 1 {name=p10 lab=i_in}
C {lab_wire.sym} 290 -80 0 1 {name=p11 lab=vref}
